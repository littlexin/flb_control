# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32f4xx (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: .;..\..\rt-thread-code\rt-thread-master\rt-thread-master\include;anop;.;applications;.;drivers;libdmp;.;Libraries\STM32F4xx_StdPeriph_Driver\inc;Libraries\CMSIS\ST\STM32F4xx\Include;Libraries\CMSIS\Include;pid;.;..\..\rt-thread-code\rt-thread-master\rt-thread-master\libcpu\arm\common;..\..\rt-thread-code\rt-thread-master\rt-thread-master\libcpu\arm\cortex-m4;..\..\rt-thread-code\rt-thread-master\rt-thread-master\components\drivers\include;..\..\rt-thread-code\rt-thread-master\rt-thread-master\components\drivers\include;..\..\rt-thread-code\rt-thread-master\rt-thread-master\components\drivers\include;..\..\rt-thread-code\rt-thread-master\rt-thread-master\components\drivers\include;..\..\rt-thread-code\rt-thread-master\rt-thread-master\components\drivers\include;..\..\rt-thread-code\rt-thread-master\rt-thread-master\components\finsh
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Kernel
    ../../rt-thread-code/rt-thread-master/rt-thread-master/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group anop
    anop/: anop.c
  group Applications
    applications/: application.c startup.c wind_swing.c
  group Drivers
    drivers/: board.c stm32f4xx_it.c platform.c usart.c gpio.c drv_hwtimer.c stm32_i2c.c drv_pwm.c
  group libdmp
    libdmp/: dmp.c inv_mpu.c inv_mpu_dmp_motion_driver.c
  group STM32_StdPeriph
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group pid
    pid/: pid.c
  group cpu
    ../../rt-thread-code/rt-thread-master/rt-thread-master/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread-code/rt-thread-master/rt-thread-master/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../rt-thread-code/rt-thread-master/rt-thread-master/components/drivers/hwtimer/: hwtimer.c
    ../../rt-thread-code/rt-thread-master/rt-thread-master/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../rt-thread-code/rt-thread-master/rt-thread-master/components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../rt-thread-code/rt-thread-master/rt-thread-master/components/drivers/serial/: serial.c
    ../../rt-thread-code/rt-thread-master/rt-thread-master/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../rt-thread-code/rt-thread-master/rt-thread-master/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
